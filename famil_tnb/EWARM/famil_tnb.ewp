# IAR project famil_tnb.ewp, settings and files
configuration famil_tnb (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM4F; ..\STemWin\Config; ..\STemWin\inc; ..\STemWin\Lib; ..\STemWin\OS; ..\UserInterface
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FreeRTOS\include
  OBJCOPY.OOCOutputFile: famil_tnb.hex
  ILINK.IlinkOutputFile: famil_tnb.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: crc.c delay.c dht11.c ds3231.c FramewinDLG.c fsmc.c gpio.c i2c.c ILI93xx.c main.c mylib.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c task_core.c task_lcd.c task_led.c task_touch.c touch.c usart.c w25qxx.c
  group Application/UserInterface
    ../UserInterface/: gui_common.c gui_keypad.c gui_warning.c ui_clock.c ui_main.c
  group Application/UserInterface/font
    ../UserInterface/font/: b_image.c font_micro_25.c font_micro_32.c font_micro_64.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c
  group EMWIN
    ../STemWin/OS/: GUI_X_OS.c
    ../STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c LCDConf_FlexColor_Template.c
    ../STemWin/Lib/: STemWin_CM4_OS_wc16.a
  group FreeRTOS/FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
